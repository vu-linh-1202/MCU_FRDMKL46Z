# IAR project LedBlinking.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 NXP MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\source; ..\CMSIS\Include; ..\MKL46Z
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: LedBlinking.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Peripheral.c PIT.h Srecord.c UART.c
  group source
    ./: CLOCK.C CLOCK.h Flash.c Flash.h PIT.C RingBuffer.c RingBuffer.h String_Handle.c String_Handle.h TPM.c
    ../source/: main.c
    ../MKL46Z/: system_MKL46Z4.c
  group startup
    ../MKL46Z/: fsl_device_registers.h MKL46Z4.h MKL46Z4_features.h startup_MKL46Z4.s system_MKL46Z4.h
